# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c include: ..\libraries\inc;..\user;..\stm32;..\cmsis
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c
  group cmsis
    ../cmsis/: startup_stm32f10x_md.s
  group stm32
    ../stm32/: stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h stm32f10x.h
  group libraries
    ../libraries/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c
