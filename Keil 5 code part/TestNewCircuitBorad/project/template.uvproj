# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c include: ..\libraries\inc;..\user;..\stm32;..\cmsis;..\bsp;..\ucosii_config;..\ucosii_core;..\ucosii_port
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c
  group cmsis
    ../cmsis/: startup_stm32f10x_md.s
  group stm32
    ../stm32/: stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h stm32f10x.h
    ../libraries/inc/: stm32f10x_dma.h
    ../libraries/src/: stm32f10x_dma.c
  group libraries
    ../libraries/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
    ../libraries/inc/: misc.h stm32f10x_tim.h
  group bsp
    ../bsp/: delay.c gpio.c key.c usart.c pwm.c delay.h key.h pwm.h usart.h Windows.h gpio.h ucosii_task.c ucosii_task.h
    ./: armcontrol.c armcontrol.h dma.c dma.h temp.c
  group ucosii_core
    ../ucosii_core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucosii_port
    ../ucosii_port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucosii_config
    ../ucosii_config/: os_cfg.h
